# Keil uVision project STM32F051_MPU_TEST.uvprojx, settings and files
target STM32F051_MPU_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F051_MPU_TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ../Core/Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;          ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Application/User/Core
    ../Core/Src/: tm_stm32_nrf24l01.c tm_stm32_spi.c tm_stm32_gpio.c tm_stm32_delay.c main.c gpio.c i2c.c spi.c sys.c tim.c stm32f0xx_it.c stm32f0xx_hal_msp.c tm_stm32_rcc.c
    ../Core/Inc/: tm_stm32_nrf24l01.h tm_stm32_spi.h tm_stm32_gpio.h tm_stm32_delay.h tm_stm32_rcc.h
    ../../../../../../../../../TM Libraries/: attributes.h tm_stm32_exti.c tm_stm32_exti.h tm_stm32_buffer.c tm_stm32_buffer.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
